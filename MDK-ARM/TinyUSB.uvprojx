# Keil uVision project TinyUSB.uvprojx, settings and files
target TinyUSB (6150000::V6.15::ARMCLANG)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: T02 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=25000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,ART_ACCLERATOR_ENABLE=1,STM32F769xx
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../Middlewares/tinyusb/src;../Middlewares/tinyusb/src/class/hid;../Middlewares/tinyusb/src/portable/st/synopsys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f7xx_it.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_gpio.c stm32f7xx_ll_rcc.c stm32f7xx_ll_utils.c stm32f7xx_ll_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/tinyusb
    ../Middlewares/tinyusb/src/: tusb.c
    ../Middlewares/tinyusb/src/class/hid/: hid_device.c
    ../Middlewares/tinyusb/src/common/: tusb_fifo.c
  group Middlewares/tinyusb/portable
    ../Middlewares/tinyusb/src/portable/st/synopsys/: dcd_synopsys.c
  group Middlewares/tinyusb/device
    ../Middlewares/tinyusb/src/device/: usbd.c usbd_control.c
    ../Core/Src/: usb_descriptors.c
software components: CMSIS:CORE 5.4.0
